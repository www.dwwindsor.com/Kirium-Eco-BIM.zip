Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-11-07T15:31:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190507_1515(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 07 15:31:20 2019 * Host: DSLAP19HP * Database: C:\Users\DANIEL~1\AppData\Local\Temp\{DE0C39B1-BD38-4E5A-9268-035D8389AC1F}\ifc * Database version: 5507 * Database creation date: Thu Nov 07 15:31:17 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 07 15:31:17 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 07 15:31:17 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowTerminal: Kirium Eco Midi, LightingFixture_DWWindsor_KiriumEco_Midi:Kirium Eco Midi:304728
In: Level 0
Pset_ManufacturerTypeInformation - Manufacturer: https://www.dwwindsor.com/
Pset_DistributionFlowElementCommon - Reference: Kirium Eco Midi
